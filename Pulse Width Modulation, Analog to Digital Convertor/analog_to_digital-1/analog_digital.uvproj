# Keil uVision project analog_digital.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: analog_digital +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../../../../analog_to_digital/: heat_sensor_simulation.c
